# Keil uVision project RM_Chassis.uvprojx, settings and files
target RM_FlyRobot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_Chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=12000000,USE_STDPERIPH_DRIVER,STM32F427_437xx,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,MPU6500,EMPL_TARGET_STM32F4
  c include: ..\..\Apps;..\..\BSP;..\..\Devices;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Apps
    ../../Apps/: delay.c Rocker.c PID.c ANO.c Cloud_control.c DevicesMonitor.c Filter.c Shoot.c debug_assert.c freeRTOSdebug.c
  group BSP
    ../../BSP/: BSP_CAN.c BSP_DMA.c BSP_GPIO.c BSP_NVIC.c BSP_TIM.c BSP_USART.c
  group Devices
    ../../Devices/: LED.c GM3510_Motor.c DR16_Receiver.c M6020_Motor.c M2006_Motor.c Fric_Motor.c GY_IMU.c JudgeSystem.c Laser.c Ultrasonic.c Watchdog.c PowerCtrl.c NDOF_IMU.c JY61.c JY901.c ComAssistant.c RM_Motor.c IMU.c N3_DJI_ASSISITANT.c
  group User
    ../../User/: main.c stm32f4xx_it.c system_stm32f4xx.c UserMath.c Init_Config.c UserTask.c
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Libraries
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group README
    ../../Doc/: readme.txt
